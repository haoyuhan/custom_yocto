require ${@bb.utils.contains('ACOS_FEATURES', 'acos-core', '${BPN}-ac.inc', '', d)}
