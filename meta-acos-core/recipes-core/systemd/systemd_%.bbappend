require ${@bb.utils.contains('ACOS_FEATURES', 'acos-core', '${BPN}_acos-core.inc', '', d)}
