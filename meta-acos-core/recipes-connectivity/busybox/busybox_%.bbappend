require ${@bb.utils.contains('ACOS_FEATURES', 'acos-core', '${BPN}_accore.inc', '', d)}
