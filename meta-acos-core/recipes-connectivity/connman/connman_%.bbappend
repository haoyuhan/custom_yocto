require ${@bb.utils.contains('ACOS_FEATURES', 'acos-core', 'connman_accore.inc', '', d)}
