require ${@bb.utils.contains('ACOS_FEATURES', 'acos-core', 'connman-conf_accore.inc', '', d)}
