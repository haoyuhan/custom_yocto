FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://0001-disable-warning-log.patch \
    file://0002-atf-debug-build.patch \
"

